# Keil uVision project Smart-lock-with-nu-lb-nuc140.uvproj, settings and files
target Smpl_Timer_SR04 (ARM-ADS)
  device: (Generic) NUC100 Series Nuvoton
  cpu: CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Smpl_Timer_SR04
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1
  c include: .\;..\..\..\..\CMSIS\CM0\CoreSupport;..\..\..\..\CMSIS\CM0\DeviceSupport\Nuvoton\NUC1xx;..\..\..\Include;..\..\..\Include\Driver;..\..\..\Include\NUC1xx-LB_002
  library: MicroLIB
  link misc: --map --first='startup_NUC1xx.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/: system_NUC1xx.c
    ../../../../CMSIS/CM0/DeviceSupport/Nuvoton/NUC1xx/startup/arm/: startup_NUC1xx.s
  group Source files
    ../../../Src/NUC1xx-LB_002/: LCD_Driver.c Ascii_Table.C ScanKey.c
    ./: Smart-lock-with-nu-lb-nuc140.c
  group Library files
    ../../../Src/Driver/: DrvSYS.c DrvGPIO.c DrvUART.c
